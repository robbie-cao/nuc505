# Keil uVision project RTOSDemo.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RTOSDemo
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: RVDS_ARMCM4_NUC505, __WINS__ OPT_SPEED
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\NUC505Series\Include;..\..\..\ThirdParty\LibMAD\inc;..\..\..\ThirdParty\FATFS\src;..\..\..\ThirdParty\FreeRTOS\SOURCE\include;..\..\..\ThirdParty\FreeRTOS\Demo\COMMON\include;..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\..\FreeRTOS;..\Mp3Lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  scatter file: .\overlay.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
    ../: startup_NUC505Series.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c i2s.c sd.c timer.c gpio.c
    ../../../ThirdParty/LibAMR/lib/: amr_codec.lib
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/SOURCE/: tasks.c timers.c list.c queue.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/RVDS/ARM_CM4F/: port.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/MemMang/: heap_2.c
  group Demo Files
    ../: main.c ParTest.c app.c diskio.c NUC505Series.h SDGlue.c ovlymgr.c usrprog_ovly_tab.c MP3HeaderParser.c
    ../../../ThirdParty/FreeRTOS/DEMO/COMMON/Minimal/: QueueSet.c PollQ.c
  group FATFS
    ../../../ThirdParty/FATFS/src/: ff.c
  group MP3Lib
    ../Mp3Lib/: AudioCommon.h Mp3.h NVTTypes.h TypeDefine.h Mp3_M4_Keil.lib
