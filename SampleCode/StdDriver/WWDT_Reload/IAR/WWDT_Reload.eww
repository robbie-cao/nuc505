<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\WWDT_Reload.ewp</path>
  </project>
  <batchBuild/>
</workspace>


