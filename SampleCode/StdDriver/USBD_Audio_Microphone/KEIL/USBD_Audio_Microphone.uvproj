# Keil uVision project USBD_Audio_Microphone.uvproj, settings and files
target USBD_Audio_Microphone (ARM-ADS)
  device: NUC505YO13Y Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x1FFFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: USBD_Audio_Microphone
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include;..\..\..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\scatter.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/ARM/: startup_NUC505Series.s
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c usbd.c i2s.c timer.c gpio.c
  group User
    ../: main.c descriptors.c usbd_audio.c config_dma.c Keypad.c
