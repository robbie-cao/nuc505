<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\I2S_NAU8822_MP3PLAYER_SD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


