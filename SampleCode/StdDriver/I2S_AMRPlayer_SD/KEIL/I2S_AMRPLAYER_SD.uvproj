# Keil uVision project I2S_AMRPLAYER_SD.uvproj, settings and files
target I2S_AMRPlayer_SD (ARM-ADS)
  device: NUC505YO13Y Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x1FFFFF) CLOCK(100000000) CPUTYPE("Cortex-M4") FPU2
  output: I2S_AMRPlayer_SD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\INCLUDE;..\..\..\..\Library\UsbHostLib\INCLUDE\inc_mass;..\..\..\..\ThirdParty\FATFS\src;..\..\..\..\ThirdParty\LibAMR\Include
  asm define: Heap_Size=0x1000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\scatter.scf
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/ARM/: startup_NUC505Series.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2s.c retarget.c sd.c sys.c uart.c
    ../../../../ThirdParty/LibAMR/lib/: amr_codec.lib
  group User
    ../: amrplayer.c diskio.c main.c nuc505_isr.c SDGlue.c
    ./: vector_remap.c
  group FATFS
    ../../../../ThirdParty/FATFS/src/: ff.c
